# Keil uVision project 06_text_relocation.uvprojx, settings and files
target 06_text_relocation (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 06_text_relocation +hex
  AfterMake: fromelf  --bin  --output=..\output\06_text_relocation.bin  ..\output\06_text_relocation.axf
  AfterMake: fromelf --text  -a -c  --output=..\output\06_text_relocation.dis  ..\output\06_text_relocation.axf
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\system\regdef;..\system\sys;..\system\typedef;..\hardware\uart;..\mystring
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\output\06_text_relocation.sct
  group user
    ./: main.c start.s
  group system
    ../system/sys/: sys.c
  group hardware
    ../hardware/uart/: uart.c
  group mystring
    ../mystring/: mystring.c
